SRC_URI = "file://weston.service \
           file://weston.ini \
           file://weston.config"
