SRC_URI = " \
    git://git.phytec.de/phyRDKDemo;protocol=https \
    file://phytec-qtdemo.service;subdir=git \
    file://PhyKitDemo.conf;subdir=git \
"
