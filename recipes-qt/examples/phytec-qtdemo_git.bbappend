FILESEXTRAPATHS_prepend := "${THISDIR}/phytec-qtdemo:"
