inherit extrausers

EXTRA_USERS_PARAMS = "useradd -m -p \$5\$ayKH.GEFr\$iE2w5eRvZr6cCBDHE10YzbNZ3wbuxbrhCL01tBzCc19 user;"
